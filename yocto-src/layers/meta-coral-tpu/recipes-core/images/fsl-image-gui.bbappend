IMAGE_INSTALL_append = " \
    python3-edgetpu-examples \
    "
