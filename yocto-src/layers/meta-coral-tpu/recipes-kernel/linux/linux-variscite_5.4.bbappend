FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0005-sai2-gpio4-io22.patch"
SRC_URI += "file://0001-removed-audio.patch"
SRC_URI += "file://0001-add-ok-for-pcie.patch"
SRC_URI += "file://0001-disable-mipi-dsi.patch"
SRC_URI += "file://0002-disable-display-phy-enable.patch"
SRC_URI += "file://gasket.cfg"
